Commit message: fix example

File: examples/anymal/anymal_b_simple_description/urdf/anymal.urdf (robot description, URDF)
Before this commit: robot anymal, 24 links, 23 joints
Links:
- removed link world
Joints:
- removed joint floating
